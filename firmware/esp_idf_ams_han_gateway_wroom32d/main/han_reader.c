#include "han_reader.h"
#include <ctype.h>
#include <stdio.h>
#include <string.h>
#include <stdlib.h>
#include <stdbool.h>
#include "driver/uart.h"
#include "esp_log.h"
#include "esp_timer.h"
#include "freertos/FreeRTOS.h"
#include "freertos/task.h"
#include "telemetry.h"

static const char *TAG = "han_reader";
static han_snapshot_callback_t s_callback = NULL;
static uint32_t s_seq = 0;
static uint32_t s_frames_rx = 0;
static uint32_t s_frames_bad = 0;
static uint64_t s_last_frame_us = 0;

static uint8_t s_frame_buf[RAW_FRAME_MAX];
static size_t s_frame_len = 0;
static bool s_frame_started = false;
static bool s_escape_next = false;

static int hex_nibble(char c) {
    if (c >= '0' && c <= '9') return c - '0';
    c = (char)toupper((unsigned char)c);
    if (c >= 'A' && c <= 'F') return c - 'A' + 10;
    return -1;
}

static bool hex_to_bytes(const char *hex, uint8_t *out, uint16_t *out_len) {
    size_t n = strlen(hex);
    if ((n % 2) != 0 || n / 2 > RAW_FRAME_MAX) {
        return false;
    }
    for (size_t i = 0; i < n; i += 2) {
        int hi = hex_nibble(hex[i]);
        int lo = hex_nibble(hex[i + 1]);
        if (hi < 0 || lo < 0) {
            return false;
        }
        out[i / 2] = (uint8_t)((hi << 4) | lo);
    }
    *out_len = (uint16_t)(n / 2);
    return true;
}

static uint32_t read_be32(const uint8_t *p) {
    return ((uint32_t)p[0] << 24) | ((uint32_t)p[1] << 16) | ((uint32_t)p[2] << 8) | ((uint32_t)p[3]);
}

static int find_pattern(const uint8_t *buf, size_t len, const uint8_t *pat, size_t pat_len) {
    if (!buf || !pat || pat_len == 0 || len < pat_len) {
        return -1;
    }
    for (size_t i = 0; i <= len - pat_len; ++i) {
        if (memcmp(buf + i, pat, pat_len) == 0) {
            return (int)i;
        }
    }
    return -1;
}

static void snapshot_set_meta(han_snapshot_t *s) {
    memset(s, 0, sizeof(*s));
    s->seq = ++s_seq;
    s->ts_ms = (uint32_t)(esp_timer_get_time() / 1000ULL);
    s->frames_rx = s_frames_rx;
    s->frames_bad = s_frames_bad;
    s->frame_age_ms = s_last_frame_us == 0 ? 0 : (uint32_t)((esp_timer_get_time() - s_last_frame_us) / 1000ULL);
}

static bool parse_csv_kv(char *line, han_snapshot_t *s) {
    bool got_any = false;
    char *saveptr = NULL;
    for (char *tok = strtok_r(line, ";", &saveptr); tok; tok = strtok_r(NULL, ";", &saveptr)) {
        char *eq = strchr(tok, '=');
        if (!eq) continue;
        *eq = '\0';
        const char *key = tok;
        const float val = strtof(eq + 1, NULL);
        if (strcmp(key, "PWR") == 0) {
            s->import_w = val;
            got_any = true;
        } else if (strcmp(key, "EXP") == 0) {
            s->export_w = val;
            got_any = true;
        } else if (strcmp(key, "QIMP") == 0) {
            s->q_import_var = val;
            got_any = true;
        } else if (strcmp(key, "QEXP") == 0) {
            s->q_export_var = val;
            got_any = true;
        } else if (strcmp(key, "L1V") == 0) {
            s->l1_v = val;
            got_any = true;
        } else if (strcmp(key, "L2V") == 0) {
            s->l2_v = val;
            got_any = true;
        } else if (strcmp(key, "L3V") == 0) {
            s->l3_v = val;
            got_any = true;
        } else if (strcmp(key, "L1A") == 0) {
            s->l1_a = val;
            got_any = true;
        } else if (strcmp(key, "L2A") == 0) {
            s->l2_a = val;
            got_any = true;
        } else if (strcmp(key, "L3A") == 0) {
            s->l3_a = val;
            got_any = true;
        }
    }
    if (got_any) {
        s->values_valid = true;
        telemetry_apply_derivations(s);
        telemetry_apply_rolling_window(s);
    }
    return got_any;
}

static bool parse_preformatted_frame(char *line, han_snapshot_t *s) {
    // This path exists for test and replay convenience: the firmware can ingest the
    // same plain-text FRAME lines that the desktop app stores in fixture logs.
    if (strncmp(line, "FRAME,", 6) != 0) return false;

    char *parts[4] = {0};
    int count = 0;
    char *saveptr = NULL;
    for (char *tok = strtok_r(line, ",", &saveptr); tok && count < 4; tok = strtok_r(NULL, ",", &saveptr)) {
        parts[count++] = tok;
    }
    if (count < 4) return false;

    uint16_t raw_len = 0;
    if (!hex_to_bytes(parts[3], s->raw, &raw_len)) return false;
    s->raw_len = raw_len;
    s->raw_valid = true;
    return true;
}

static bool parse_kaifa_kfm001(const uint8_t *buf, size_t len, han_snapshot_t *s) {
    const uint8_t list_pattern[] = {0x09, 0x07, 'K', 'F', 'M', '_', '0', '0', '1'};
    int list_pos = find_pattern(buf, len, list_pattern, sizeof(list_pattern));
    if (list_pos < 0) {
        return false;
    }

    const uint8_t clock_pattern[] = {0x09, 0x0C};
    int clock_pos = -1;
    for (int i = 0; i <= list_pos - 2; ++i) {
        if (buf[i] == clock_pattern[0] && buf[i + 1] == clock_pattern[1]) {
            clock_pos = i;
            break;
        }
    }
    if (clock_pos < 0 || (size_t)(clock_pos + 14) > len) {
        return false;
    }

    const uint8_t *t = buf + clock_pos + 2;
    s->year = (uint16_t)(((uint16_t)t[0] << 8) | t[1]);
    s->month = t[2];
    s->day = t[3];
    s->hour = t[5];
    s->minute = t[6];
    s->second = t[7];

    memcpy(s->list_id, "KFM_001", 7);
    s->list_id[7] = '\0';

    size_t p = (size_t)list_pos + sizeof(list_pattern);

    if (p + 18 > len || buf[p] != 0x09 || buf[p + 1] != 0x10) {
        return false;
    }
    memcpy(s->meter_id, buf + p + 2, 16);
    s->meter_id[16] = '\0';
    p += 18;

    if (p + 10 > len || buf[p] != 0x09 || buf[p + 1] != 0x08) {
        return false;
    }
    memcpy(s->meter_type, buf + p + 2, 8);
    s->meter_type[8] = '\0';
    p += 10;

    // The field order stays positional so the emitted SNAP contract matches the
    // Python parser and replay fixtures exactly.
    uint32_t vals[10] = {0};
    for (uint8_t i = 0; i < 10; ++i) {
        if (p + 5 > len || buf[p] != 0x06) {
            return false;
        }
        vals[i] = read_be32(buf + p + 1);
        p += 5;
    }

    s->import_w = (float)vals[0];
    s->export_w = (float)vals[1];
    s->q_import_var = (float)vals[2];
    s->q_export_var = (float)vals[3];
    s->l1_a = (float)vals[4] / 1000.0f;
    s->l2_a = (float)vals[5] / 1000.0f;
    s->l3_a = (float)vals[6] / 1000.0f;
    s->l1_v = (float)vals[7] / 10.0f;
    s->l2_v = (float)vals[8] / 10.0f;
    s->l3_v = (float)vals[9] / 10.0f;

    s->values_valid = true;
    s->kaifa_valid = true;
    telemetry_apply_derivations(s);
    telemetry_apply_rolling_window(s);
    return true;
}

static void deliver_snapshot(han_snapshot_t *s) {
    s_frames_rx++;
    s->frames_rx = s_frames_rx;
    s->frames_bad = s_frames_bad;
    s_last_frame_us = esp_timer_get_time();
    s->frame_age_ms = 0;
    if (s_callback) {
        s_callback(s);
    }
}

static void process_raw_frame(const uint8_t *frame, size_t len) {
    if (!frame || len == 0 || len > RAW_FRAME_MAX) {
        s_frames_bad++;
        return;
    }

    han_snapshot_t s;
    snapshot_set_meta(&s);
    memcpy(s.raw, frame, len);
    s.raw_len = (uint16_t)len;
    s.raw_valid = true;

    if (parse_kaifa_kfm001(frame, len, &s)) {
        deliver_snapshot(&s);
    } else {
        // Still forward raw frames to the PC for compatibility and debugging.
        deliver_snapshot(&s);
    }
}

static void handle_incoming_byte(uint8_t b) {
    if (b == 0x7E) {
        if (s_frame_started && s_frame_len > 0) {
            process_raw_frame(s_frame_buf, s_frame_len);
        }
        s_frame_started = true;
        s_frame_len = 0;
        s_escape_next = false;
        return;
    }

    if (!s_frame_started) {
        return;
    }

    if (b == 0x7D) {
        s_escape_next = true;
        return;
    }

    if (s_escape_next) {
        // Standard HDLC byte-stuffing used by the HAN stream.
        b ^= 0x20;
        s_escape_next = false;
    }

    if (s_frame_len < RAW_FRAME_MAX) {
        s_frame_buf[s_frame_len++] = b;
    } else {
        s_frame_started = false;
        s_frame_len = 0;
        s_escape_next = false;
        s_frames_bad++;
        ESP_LOGW(TAG, "Frame overflow - dropped");
    }
}

static void han_task(void *arg) {
    (void)arg;
    uint8_t *buf = malloc(HAN_UART_BUF_SIZE);
    char line[SERIAL_LINE_MAX];
    size_t line_len = 0;

    while (1) {
        int len = uart_read_bytes(HAN_UART_NUM, buf, HAN_UART_BUF_SIZE, pdMS_TO_TICKS(200));
        if (len <= 0) {
            continue;
        }

        for (int i = 0; i < len; ++i) {
            uint8_t b = buf[i];

            // Raw HAN path first: HDLC-style framed binary stream.
            if (b == 0x7E || s_frame_started) {
                handle_incoming_byte(b);
                continue;
            }

            // Convenience fallback for test/debug ASCII inputs.
            if (b == '\n' || b == '\r') {
                if (line_len == 0) {
                    continue;
                }
                line[line_len] = '\0';
                han_snapshot_t s;
                snapshot_set_meta(&s);
                bool ok = false;
                if (strncmp(line, "FRAME,", 6) == 0) {
                    ok = parse_preformatted_frame(line, &s);
                    if (ok) {
                        parse_kaifa_kfm001(s.raw, s.raw_len, &s);
                    }
                } else {
                    ok = parse_csv_kv(line, &s);
                    if (!ok) {
                        s.raw_len = (uint16_t)(line_len < RAW_FRAME_MAX ? line_len : RAW_FRAME_MAX);
                        memcpy(s.raw, line, s.raw_len);
                        s.raw_valid = true;
                        ok = true;
                    }
                }
                if (ok) {
                    deliver_snapshot(&s);
                } else {
                    s_frames_bad++;
                    ESP_LOGW(TAG, "Bad ASCII frame");
                }
                line_len = 0;
                continue;
            }

            if (isprint((int)b) && line_len + 1 < sizeof(line)) {
                line[line_len++] = (char)b;
            } else if (line_len > 0) {
                line_len = 0;
            }
        }
    }
}

void han_reader_init(han_snapshot_callback_t callback) {
    s_callback = callback;

    const uart_config_t uart_cfg = {
        .baud_rate = HAN_UART_BAUDRATE,
        .data_bits = UART_DATA_8_BITS,
        .parity = UART_PARITY_DISABLE,
        .stop_bits = UART_STOP_BITS_1,
        .flow_ctrl = UART_HW_FLOWCTRL_DISABLE,
        .source_clk = UART_SCLK_DEFAULT,
    };

    ESP_ERROR_CHECK(uart_driver_install(HAN_UART_NUM, HAN_UART_BUF_SIZE, 0, 0, NULL, 0));
    ESP_ERROR_CHECK(uart_param_config(HAN_UART_NUM, &uart_cfg));
    ESP_ERROR_CHECK(uart_set_pin(HAN_UART_NUM, HAN_UART_TX_PIN, HAN_UART_RX_PIN, UART_PIN_NO_CHANGE, UART_PIN_NO_CHANGE));

    xTaskCreate(han_task, "han_task", 6144, NULL, 7, NULL);
}
